# Repository shinchiryota/Circuit (continued)

## EAGLE design 2022/unitbase_keinz_2022/Unitbase_Keinz_2022.brd

File 2022/unitbase_keinz_2022/README.md:

# Unitbase_Keinz_2022

高専ロボコン2022で使用されるUnitbase回路。  
現在の内容は印字等の修正が含まれているため部室にある回路とは厳密には異なる。  
部室にある回路のデータは、以下のcommitの中にある。  

commit #22d5f8b0ac3ca70e439e2381a5ce0f51943bfda6

Parts:
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 100n; CAPC1709X100N
C17: 4.7u; CAPC1709X100N
C20, C21: 2.2u; CAPC1709X100N
C22: 100n; CAPC1608X90N
C23: 0.1u; CAPC1709X100N
C24: 10u; CAPC1608X90N
IC1: STM32F732RET6; QFP50P1200X1200X160-64N@1
IC3: NCV7351D1ER2G; SOIC127P600X175-8N
J2: USB-4AF203AS; USB4AF203AS
JP1: none; 2X03
LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED24, LED25, LED30, LED31: LED1608
R1, R54, R60, R66, R68: 10k; SMD1608
R2, R3, R4, R5, R7, R8, R11, R12: 1k; R0603
R9: 120; 1608
R59, R61, R67, R69: 1k; SMD1608
S2: TSHA-T-2.5B2-19E; TSHAT25B219E
SL1: None; 06PA
TR21, TR22, TR25, TR26: 2SC2712GR; SOT-23
U1: LD1117S33CTR; SOT223
X1, X2, X5: B2B-XH-2; B2B-XH-A
X3: B3B-XH-2; B3B-XH-A
X6, X9: S5B-XH-A
X7: B4B-XH-2; B4B-XH-A

Connections:
3V3: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C20.2, C21.2, C24.2, IC1.1 (VBAT), IC1.13 (VREF+), IC1.19 (VDD_1), IC1.30 (VCAP_1), IC1.32 (VDD_2), IC1.48 (VDD_3), IC1.64 (VDD_4), LED2.A, SL1.1, U1.2 (OUT), U1.4 (OUT), X3.2; also elsewhere on the board
5V: C22.2, IC3.3 (VCC), IC3.5 (EN), J2.1, J2.5, LED3.A, R59.1, R61.1, R67.1, R69.1, U1.3 (IN), X3.1, X6.4, X9.4
CAN1_RX: IC1.44 (PA11), IC3.4 (RXD), LED5.A
CAN1_TX: IC1.45 (PA12), IC3.1 (TXD), LED4.A
CANH: IC3.7 (CANH), J2.2, J2.6, R9.2
CANL: IC3.6 (CANL), J2.3, J2.7, R9.1
EN1A: IC1.41 (PA8), R54.1, X6.5
EN1B: IC1.42 (PA9), R60.1, X6.3
EN2A: IC1.37 (PC6), R66.1, X9.5
EN2B: IC1.38 (PC7), R68.1, X9.3
GND: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C20.1, C21.1, C22.1, C23.1, C24.1, IC1.12 (VSSA), IC1.18 (VSS_1), IC1.31 (VSS_2), IC1.47 (VSS_3), IC1.63 (VSS_4), IC3.2 (GND), IC3.8 (S), J2.4, J2.8, R1.1, R2.2, R3.2, R4.2, R5.2, R7.2, R8.2, R11.2, R12.2, S2.C1 (COM_1), S2.D1 (COM_2), SL1.3, TR21.2 (S), TR22.2 (S), TR25.2 (S), TR26.2 (S), U1.1 (GND), X1.2, X3.3, X6.1, X9.1; also elsewhere on the board
I2C2_SCL: IC1.28 (PB10), X5.2
I2C2_SDA: IC1.29 (PB11), X5.1
MD1A: IC1.21 (PA5); also elsewhere on the board
MD1B: IC1.55 (PB3); also elsewhere on the board
MD2A: IC1.16 (PA2); also elsewhere on the board
MD2B: IC1.17 (PA3); also elsewhere on the board
MD3A: IC1.22 (PA6); also elsewhere on the board
MD3B: IC1.23 (PA7); also elsewhere on the board
MD4A: IC1.25 (PB0); also elsewhere on the board
MD4B: IC1.26 (PB1); also elsewhere on the board
MD5A: IC1.14 (PA0-WKUP); also elsewhere on the board
MD5B: IC1.15 (PA1); also elsewhere on the board
unnamed: LED7.K, R8.1
unnamed: IC1.60 (BOOT0), R1.2
unnamed: LED2.K, R3.1
unnamed: LED3.K, R4.1
unnamed: LED5.K, R5.1
unnamed: LED4.K, R2.1
unnamed: R54.2, TR22.1 (G)
unnamed: LED24.K, TR22.3 (D)
unnamed: LED6.K, R7.1
unnamed: LED9.K, R12.1
unnamed: LED24.A, R59.2
unnamed: LED8.K, R11.1
unnamed: R60.2, TR21.1 (G)
unnamed: LED25.K, TR21.3 (D)
unnamed: LED25.A, R61.2
unnamed: R66.2, TR26.1 (G)
unnamed: LED30.K, TR26.3 (D)
unnamed: LED30.A, R67.2
unnamed: R68.2, TR25.1 (G)
unnamed: LED31.K, TR25.3 (D)
unnamed: LED31.A, R69.2
NRST: C23.2, IC1.7 (NRST), S2.A1 (NO_1), SL1.5, X1.1
PB12: IC1.33 (PB12), JP1.5
PB13: IC1.34 (PB13), JP1.3
PB14: IC1.35 (PB14), JP1.1
PC1: IC1.9 (PC1), JP1.6
PC2: IC1.10 (PC2), JP1.4
PC3: IC1.11 (PC3), JP1.2
PC14: IC1.3 (PC14-OSC32_IN), LED9.A
PC15: IC1.4 (PC15-OSC32_OUT), LED8.A
PH0: IC1.5 (PH0-OSC_IN), LED7.A
PH1: IC1.6 (PH1-OSC_OUT), LED6.A
SPI3_MISO: IC1.52 (PC11), X7.2
SPI3_MOSI: IC1.53 (PC12), X7.1
SPI3_NSS: IC1.50 (PA15), X7.4
SPI3_SCK: IC1.51 (PC10), X7.3
SWCLK: IC1.49 (PA14), SL1.2
SWDIO: IC1.46 (PA13), SL1.4
USART1_RX: IC1.59 (PB7), X2.2
USART1_TX: IC1.58 (PB6), X2.1

Notes on the sheet:
gpio
インジゲータ用(gpio)
VDD-VSS
Power Supply Sheme
stm32f732ret6
Write/Debug
spi
5v 3v3 gnd
電源確認用
CAN通信確認用
インジゲータ用LED
I/O
Power Supply
Encorder(PWM)
←I/O 電流増幅→
Circuitname: Unitbase_Keinz_2022 @Keinz_3256_KK
SWO
電源様式はマイコンの破壊防止のために実装する物である。

Parts:
C1, C2, C3, C4: 25PK470MEFC8X11.5; CAPPRD350W60D825H1150
J1, J3, J4, J5, J6: 217026SE
LED1: LED1608
R10: 10k; R0603
X4: B2B-XH-A

Connections:
3V3: J1.21, J1.22, J3.21, J3.22, J4.21, J4.22, J5.21, J5.22, J6.21, J6.22; also elsewhere on the board
12V: C1.1 (+), C2.1 (+), C3.1 (+), C4.1 (+), J1.1, J1.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J1.9, J1.10, J3.1, J3.2, J3.3, J3.4, J3.5, J3.6, J3.7, J3.8, J3.9, J3.10, J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, J4.9, J4.10, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.9, J5.10, J6.1, J6.2, J6.3, J6.4, J6.5, J6.6, J6.7, J6.8, J6.9, J6.10, R10.1, X4.1
GND-M: C1.2 (-), C2.2 (-), C3.2 (-), C4.2 (-), J1.11, J1.12, J1.13, J1.14, J1.15, J1.16, J1.17, J1.18, J1.19, J1.20, J3.11, J3.12, J3.13, J3.14, J3.15, J3.16, J3.17, J3.18, J3.19, J3.20, J4.11, J4.12, J4.13, J4.14, J4.15, J4.16, J4.17, J4.18, J4.19, J4.20, J5.11, J5.12, J5.13, J5.14, J5.15, J5.16, J5.17, J5.18, J5.19, J5.20, J6.11, J6.12, J6.13, J6.14, J6.15, J6.16, J6.17, J6.18, J6.19, J6.20, LED1.K, X4.2
unnamed: LED1.A, R10.2
PA0: J6.25, J6.26; also elsewhere on the board
PA1: J6.23, J6.24; also elsewhere on the board
PA2: J3.25, J3.26; also elsewhere on the board
PA3: J3.23, J3.24; also elsewhere on the board
PA5: J1.25, J1.26; also elsewhere on the board
PA6: J4.25, J4.26; also elsewhere on the board
PA7: J4.23, J4.24; also elsewhere on the board
PB0: J5.25, J5.26; also elsewhere on the board
PB1: J5.23, J5.24; also elsewhere on the board
PB3: J1.23, J1.24; also elsewhere on the board

Notes on the sheet:
MD-12V
md1
md2
md3
md4
md5

Parts:
LED11, LED12, LED13, LED14, LED16, LED17, LED20, LED21, LED26, LED27: LED1608
Q1, Q2, Q3, Q4, Q5, Q7, Q10, Q11, Q15, Q16: 2SA1162GRTE85LF
R6, R22, R25, R28, R31, R37, R46, R49, R62, R65: 1k; SMD1608
R20, R21, R23, R24, R26, R27, R29, R30, R35, R36, R38, R39, R47, R48, R50, R51, R63, R64, R70, R71: 10k; SMD1608
TR6, TR7, TR8, TR9, TR11, TR12, TR15, TR16, TR19, TR20: 2SC2712GR; SOT-23

Connections:
3V3: LED11.A, LED12.A, LED13.A, LED14.A, LED16.A, LED17.A, LED20.A, LED21.A, LED26.A, LED27.A; also elsewhere on the board
GND: Q1.3 (C), Q2.3 (C), Q3.3 (C), Q4.3 (C), Q5.3 (C), Q7.3 (C), Q10.3 (C), Q11.3 (C), Q15.3 (C), Q16.3 (C), TR6.2 (S), TR7.2 (S), TR8.2 (S), TR9.2 (S), TR11.2 (S), TR12.2 (S), TR15.2 (S), TR16.2 (S), TR19.2 (S), TR20.2 (S); also elsewhere on the board
MD1A: R20.1, R21.1; also elsewhere on the board
MD1B: R23.1, R24.1; also elsewhere on the board
MD2A: R35.1, R36.1; also elsewhere on the board
MD2B: R38.1, R39.1; also elsewhere on the board
MD3A: R26.1, R27.1; also elsewhere on the board
MD3B: R29.1, R30.1; also elsewhere on the board
MD4A: R47.1, R48.1; also elsewhere on the board
MD4B: R50.1, R51.1; also elsewhere on the board
MD5A: R63.1, R64.1; also elsewhere on the board
MD5B: R70.1, R71.1; also elsewhere on the board
unnamed: R6.1, TR6.3 (D)
unnamed: R20.2, TR6.1 (G)
unnamed: LED11.K, R6.2
unnamed: R22.1, TR7.3 (D)
unnamed: R23.2, TR7.1 (G)
unnamed: LED12.K, R22.2
unnamed: Q1.1 (B), R24.2
unnamed: Q2.1 (B), R21.2
unnamed: R25.1, TR8.3 (D)
unnamed: R26.2, TR8.1 (G)
unnamed: LED13.K, R25.2
unnamed: R28.1, TR9.3 (D)
unnamed: R29.2, TR9.1 (G)
unnamed: LED14.K, R28.2
unnamed: Q3.1 (B), R30.2
unnamed: Q4.1 (B), R27.2
unnamed: R31.1, TR11.3 (D)
unnamed: R35.2, TR11.1 (G)
unnamed: LED16.K, R31.2
unnamed: R37.1, TR12.3 (D)
unnamed: R38.2, TR12.1 (G)
unnamed: LED17.K, R37.2
unnamed: Q5.1 (B), R39.2
unnamed: Q7.1 (B), R36.2
unnamed: R46.1, TR15.3 (D)
unnamed: R47.2, TR15.1 (G)
unnamed: LED20.K, R46.2
unnamed: R49.1, TR16.3 (D)
unnamed: R50.2, TR16.1 (G)
unnamed: LED21.K, R49.2
unnamed: Q10.1 (B), R51.2
unnamed: Q11.1 (B), R48.2
unnamed: R62.1, TR19.3 (D)
unnamed: R63.2, TR19.1 (G)
unnamed: LED26.K, R62.2
unnamed: R65.1, TR20.3 (D)
unnamed: R70.2, TR20.1 (G)
unnamed: LED27.K, R65.2
unnamed: Q15.1 (B), R71.2
unnamed: Q16.1 (B), R64.2
PA0: Q16.2 (E); also elsewhere on the board
PA1: Q15.2 (E); also elsewhere on the board
PA2: Q7.2 (E); also elsewhere on the board
PA3: Q5.2 (E); also elsewhere on the board
PA5: Q2.2 (E); also elsewhere on the board
PA6: Q4.2 (E); also elsewhere on the board
PA7: Q3.2 (E); also elsewhere on the board
PB0: Q11.2 (E); also elsewhere on the board
PB1: Q10.2 (E); also elsewhere on the board
PB3: Q1.2 (E); also elsewhere on the board

Notes on the sheet:
電流増幅用回路(PWM)
1ベース、2コレクタ、3エミッタ
pa5
pb3
pa2
pa3
pa6
pa7
pb0
pb1
pa0
pa1

Board: 2 copper layers, 100.0 x 100.0 mm, 138 parts (50 on the bottom side), 116 nets.

## EAGLE design 2022/servo_solenoidvalve_of_Tatebayashi/Servosolenoidvalve_of_Tatebayashi.brd

Parts:
C1, C9, C10, C11: 100n; CAPC1709X100N
C2: 10uF; CAPC1608X90N
C5: 25PK470MEFC8X11.5; CAPPRD350W60D825H1150
C17: 4.7u; CAPC1709X100N
C18: 10n; CAPC1709X100N
C19: 1u; CAPC1709X100N
C22: 100n; CAPC1608X90N
C23: 0.1u; CAPC1709X100N
IC1: STM32F302RBT6; QFP50P1200X1200X160-64N
IC2: NCV7351D1ER2G; SOIC127P600X175-8N
J2: USB-4AF203AS; USB4AF203AS
JP1, JP2, JP3: PINHD-1X3; 1X03
LED2, LED3, LED14, LED15, LED16, LED17, LED29, LED40, LED41, LED50, LED51-G, LED52-Y: LED1608
Q9, Q10: SOT-23_NMOS; SOT-23
R1: 10k; 1608
R2, R3, R118: 1k; R0603
R5: 120; R0805
R9, R11, R59, R61, R63, R65, R121, R122: 10k; SMD1608
R10, R20, R60, R62, R64, R66, R119, R120: 1k; SMD1608
R25: 10k; R0603
S2: TSHA-T-2.5B2-19E; TSHAT25B219E
SL1: MA06; 06PA
TR12, TR13, TR14, TR17, TR21, TR22: 2SC2712GR; SOT-23
U1: LD1117S33CTR; SOT223
X8: S4B-XH-A
X18, X19: S2B-XH-A
X22: S3B-XH-A
X25: B2B-XH-A

Connections:
3V3: C1.2, C2.2, C9.2, C10.2, C11.2, C17.2, C18.2, C19.2, IC1.1 (VBAT), IC1.13 (VDDA), IC1.19 (VDD_1), IC1.32 (VDD_2), IC1.48 (VDD_3), IC1.64 (VDD_4), LED3.A, SL1.1, U1.2 (OUT), U1.4 (OUT), X22.2; also elsewhere on the board
5V: C22.2, IC2.3 (VCC), IC2.5 (EN), J2.1, J2.5, LED51-G.A, LED52-Y.A, R2.1, R10.1, R20.1, R60.1, R62.1, R64.1, R66.1, U1.3 (IN), X22.1
12V: C5.1 (+), LED41.A, X25.1; also elsewhere on the board
CANH: IC2.7 (CANH), J2.2, J2.6, R5.2
CANL: IC2.6 (CANL), J2.3, J2.7, R5.1
CAN_RX: IC1.44 (PA11), IC2.4 (RXD), R122.2
CAN_TX: IC1.45 (PA12), IC2.1 (TXD), R121.2
DCDC_OUT: R118.1; also elsewhere on the board
GND: C1.1, C2.1, C9.1, C10.1, C11.1, C17.1, C18.1, C19.1, C22.1, C23.1, IC1.12 (VSSA/VREF-), IC1.31 (VSS_1), IC1.47 (VSS_2), IC1.63 (VSS_3), IC2.2 (GND), IC2.8 (S), J2.4, J2.8, LED2.K, Q9.2 (S), Q10.2 (S), R1.2, R3.2, S2.C1 (COM_1), S2.D1 (COM_2), SL1.3, TR12.2 (S), TR13.2 (S), TR14.2 (S), TR17.2 (S), TR21.2 (S), TR22.2 (S), U1.1 (GND), X22.3; also elsewhere on the board
GND-M: C5.2 (-), LED50.K, R25.2, X25.2; also elsewhere on the board
unnamed: LED2.A, R2.2
unnamed: LED3.K, R3.1
unnamed: IC1.60 (BOOT0), R1.1
unnamed: R59.2, TR12.1 (G)
unnamed: LED14.K, TR12.3 (D)
unnamed: LED14.A, R60.2
unnamed: R61.2, TR13.1 (G)
unnamed: LED15.K, TR13.3 (D)
unnamed: LED15.A, R62.2
unnamed: R63.2, TR14.1 (G)
unnamed: LED16.K, TR14.3 (D)
unnamed: LED16.A, R64.2
unnamed: R65.2, TR17.1 (G)
unnamed: LED17.K, TR17.3 (D)
unnamed: LED17.A, R66.2
unnamed: R9.2, TR21.1 (G)
unnamed: LED29.K, TR21.3 (D)
unnamed: LED29.A, R10.2
unnamed: R11.2, TR22.1 (G)
unnamed: LED40.K, TR22.3 (D)
unnamed: LED40.A, R20.2
unnamed: LED41.K, R25.1
unnamed: Q9.1 (G), R121.1
unnamed: Q10.1 (G), R122.1
unnamed: LED51-G.K, R119.1
unnamed: LED52-Y.K, R120.1
unnamed: LED50.A, R118.2
unnamed: Q9.3 (D), R119.2
unnamed: Q10.3 (D), R120.2
NRST: C23.2, IC1.7 (NRST), S2.A1 (NO_1), SL1.5
PA8: IC1.41 (PA8), JP1.1
PB5: IC1.57 (PB5), R61.1
PB6: IC1.58 (PB6), R63.1
PB7: IC1.59 (PB7), R65.1
PB8: IC1.61 (PB8), R9.1
PB12: IC1.33 (PB12), JP3.3
PB13: IC1.34 (PB13), JP3.2
PB14: IC1.35 (PB14), JP3.1
PB15: IC1.36 (PB15), JP2.3
PC6: IC1.37 (PC6), JP2.2
PC7: IC1.38 (PC7), JP2.1
PC8: IC1.39 (PC8), JP1.3
PC9: IC1.40 (PC9), JP1.2
PC13: IC1.2 (PC13), R11.1
PD2: IC1.54 (PD2), R59.1
SCL: IC1.42 (PA9), X19.2
SDA: IC1.43 (PA10), X19.1
SIGNAL-SE_1: IC1.30 (PB11); also elsewhere on the board
SIGNAL-SE_2: IC1.29 (PB10); also elsewhere on the board
SIGNAL-SE_3: IC1.27 (PB1); also elsewhere on the board
SIGNAL-SE_4: IC1.26 (PB0); also elsewhere on the board
SIGNAL-SE_5: IC1.23 (PA7); also elsewhere on the board
SIGNAL-SE_6: IC1.22 (PA6); also elsewhere on the board
SIGNAL-SE_7: IC1.21 (PA5); also elsewhere on the board
SIGNAL-SE_8: IC1.20 (PA4); also elsewhere on the board
SIGNAL-SE_9: IC1.17 (PA3); also elsewhere on the board
SIGNAL-SE_10: IC1.16 (PA2); also elsewhere on the board
SIGNAL-SE_11: IC1.15 (PA1); also elsewhere on the board
SIGNAL-SE_12: IC1.62 (PB9); also elsewhere on the board
SIGNAL-SO_1: IC1.11 (PC3); also elsewhere on the board
SIGNAL-SO_2: IC1.10 (PC2); also elsewhere on the board
SIGNAL-SO_3: IC1.9 (PC1); also elsewhere on the board
SIGNAL-SO_4: IC1.8 (PC0); also elsewhere on the board
SIGNAL-SO_5: IC1.6 (PF1/OSC_OUT); also elsewhere on the board
SIGNAL-SO_6: IC1.5 (PF0/OSC_IN); also elsewhere on the board
SIGNAL-SO_7: IC1.4 (PC15/OSC32_OUT); also elsewhere on the board
SIGNAL-SO_8: IC1.3 (PC14/OSC32_IN); also elsewhere on the board
SPI_MISO: IC1.52 (PC11), X8.2
SPI_MOSI: IC1.53 (PC12), X8.1
SPI_NSS: IC1.50 (PA15), X8.4
SPI_SCK: IC1.51 (PC10), X8.3
SWCLK: IC1.49 (PA14), SL1.2
SWDIO: IC1.46 (PA13), SL1.4
SWO: SL1.6
USART_RX: IC1.56 (PB4), X18.2
USART_TX: IC1.55 (PB3), X18.1

Notes on the sheet:
Write/Debug
indicator
spi
VDD-VSS
VDDA-VSSA
5v 3v3 gnd
regulator
reset button
usb
usart
i2c
can
12v
Blue LED
Red LED
