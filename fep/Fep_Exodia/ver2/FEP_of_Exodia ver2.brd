# Repository shinchiryota/Circuit (continued)

## EAGLE design 2024/nhk2024/Sensormain_Exodia/sensormain_Exodia ver2.brd (continued)

Board: 2 copper layers, 100.0 x 100.0 mm, 204 parts (125 on the bottom side), 152 nets.

## EAGLE design 2022/controller_keinz_2022/Controller_Keinz_2022.brd

File 2022/README.md:

# 2022

# [始めに戻る](https://github.com/shinchiryota/Circuit/blob/main/README.md)

Parts:
C1, C2, C3, C4, C12: 100n; C0603K
C5: 4.7u; C0603K
C6: 10n; C0603K
C7: 1u; C0603K
C11: 10u; C0603K
FEP_1: GOD_OF_FEP
IC1: STM32F302C8T6; QFP50P900X900X160-48N
IC2: MCP3208-CI_P; DIP781W56P254L1918H533Q16N
IC3: LD1117S33CTR; SOT230P700X190-4N
Q1, Q4, Q6, Q8: BSS138LT7G; SOT96P237X111-3N
R8: 10k; R0603@1
R11, R12, R17, R18, R21, R22, R25, R26: 10k; SMD1608
X1: PN87520-S
X22: B2B-XH-2; B2B-XH-A

Connections:
3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C11.1, IC1.1 (VBAT), IC1.9 (VDDA/VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC3.2 (VOUT), IC3.4 (VOUT_1), Q1.1 (G), Q4.1 (G), Q6.1 (G), Q8.1 (G), R11.1, R17.1, R21.1, R25.1; also elsewhere on the board
5V: C12.1, FEP_1.P17 (5V), IC2.15 (VREF), IC2.16 (VDD), IC3.3 (VIN), R12.1, R18.1, R22.1, R26.1, X22.2; also elsewhere on the board
5V_MISO: IC2.12 (DOUT), Q1.3 (D), R12.2
5V_MOSI: IC2.11 (DIN), Q8.3 (D), R26.2
5V_NSS: IC2.10 (!CS!/SHDN), Q6.3 (D), R22.2
5V_SCK: IC2.13 (CLK), Q4.3 (D), R18.2
5V_USB: X1.1, X22.1
ADC-0: IC2.1 (CH0); also elsewhere on the board
ADC-1: IC2.2 (CH1); also elsewhere on the board
ADC-2: IC2.3 (CH2); also elsewhere on the board
ADC-3: IC2.4 (CH3); also elsewhere on the board
ADC-4: IC2.5 (CH4); also elsewhere on the board
ADC-5: IC2.6 (CH5); also elsewhere on the board
ADC-6: IC2.7 (CH6); also elsewhere on the board
ADC-7: IC2.8 (CH7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C11.2, C12.2, FEP_1.P18 (GND), IC1.8 (VSSA/VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.9 (DGND), IC2.14 (AGND), IC3.1 (GROUND), R8.1, X1.4; also elsewhere on the board
I2C1_SCL: IC1.42 (PB6); also elsewhere on the board
I2C1_SDA: IC1.43 (PB7); also elsewhere on the board
I2C2_SCL: IC1.6 (PF1-OSC_OUT); also elsewhere on the board
I2C2_SDA: IC1.5 (PF0-OSC_IN); also elsewhere on the board
unnamed: IC1.44 (BOOT0), R8.2
NRST: IC1.7 (NRST); also elsewhere on the board
PA0: IC1.10 (PA0); also elsewhere on the board
PA1: IC1.11 (PA1); also elsewhere on the board
PA2: IC1.12 (PA2); also elsewhere on the board
PA3: IC1.13 (PA3); also elsewhere on the board
PA5: IC1.15 (PA5); also elsewhere on the board
PA6: IC1.16 (PA6); also elsewhere on the board
PA7: IC1.17 (PA7); also elsewhere on the board
PB0: IC1.18 (PB0); also elsewhere on the board
PB1: IC1.19 (PB1); also elsewhere on the board
PB2: IC1.20 (PB2); also elsewhere on the board
PB10: IC1.21 (PB10); also elsewhere on the board
PB11: IC1.22 (PB11); also elsewhere on the board
PB12: IC1.25 (PB12); also elsewhere on the board
PB13: IC1.26 (PB13); also elsewhere on the board
PB14: IC1.27 (PB14); also elsewhere on the board
PB15: IC1.28 (PB15); also elsewhere on the board
PC13: IC1.2 (PC13); also elsewhere on the board
SPI3_MISO: IC1.40 (PB4), Q1.2 (S), R11.2
SPI3_MOSI: IC1.41 (PB5), Q8.2 (S), R25.2
SPI3_NSS: IC1.38 (PA15), Q6.2 (S), R21.2
SPI3_SCK: IC1.39 (PB3), Q4.2 (S), R17.2
SWCLK: IC1.37 (PA14); also elsewhere on the board
SWDIO: IC1.34 (PA13); also elsewhere on the board
USART1_CTS: FEP_1.P12 (CTS), IC1.32 (PA11)
USART1_RTS: FEP_1.P13 (RTS), IC1.33 (PA12)
USART1_RX: FEP_1.P14 (DATA_RX), IC1.31 (PA10)
USART1_TX: FEP_1.P15 (DATA_TX), IC1.30 (PA9)

Notes on the sheet:
VDD-VSS
VDDA-VSSA
Level-Shift
Power Supply
Power Supply Sheme
FEP module
ADC-IC
Controller_Keinz_2022

Parts:
C13: 0.1u; C0603K
CN3, CN14: B4B-XH-2; B4B-XH-A
JP1: PINHD-2X13; 2X13
S1: DTSM-65N-V-T_R; DTSM65NVTR
SL1: MA06; 06PA
X2, X3: B4B-XH-2; B4B-XH-A

Connections:
3V3: CN3.1, CN14.1, SL1.1; also elsewhere on the board
5V: X2.1, X3.1; also elsewhere on the board
ADC-0: X2.2; also elsewhere on the board
ADC-1: X2.3; also elsewhere on the board
ADC-2: X3.2; also elsewhere on the board
ADC-3: X3.3; also elsewhere on the board
ADC-4: JP1.21; also elsewhere on the board
ADC-5: JP1.23; also elsewhere on the board
ADC-6: JP1.25; also elsewhere on the board
GND: C13.2, CN3.4, CN14.4, JP1.2, JP1.4, JP1.6, JP1.8, JP1.10, JP1.12, JP1.14, JP1.16, JP1.18, JP1.20, JP1.22, JP1.24, JP1.26, S1.3 (NO_1), SL1.3, X2.4, X3.4; also elsewhere on the board
I2C1_SCL: CN14.2; also elsewhere on the board
I2C1_SDA: CN14.3; also elsewhere on the board
I2C2_SCL: CN3.2; also elsewhere on the board
I2C2_SDA: CN3.3; also elsewhere on the board
NRST: C13.1, S1.1 (COM_1), SL1.5; also elsewhere on the board
PA0: JP1.17; also elsewhere on the board
PA3: JP1.15; also elsewhere on the board
PA5: JP1.13; also elsewhere on the board
PA6: JP1.11; also elsewhere on the board
PA7: JP1.9; also elsewhere on the board
PB0: JP1.7; also elsewhere on the board
PB1: JP1.5; also elsewhere on the board
PB2: JP1.3; also elsewhere on the board
PB12: JP1.1; also elsewhere on the board
PC13: JP1.19; also elsewhere on the board
SWCLK: SL1.2; also elsewhere on the board
SWDIO: SL1.4; also elsewhere on the board
SWO: SL1.6

Notes on the sheet:
I/O

Parts:
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: LEDCHIP-LED0805; CHIP-LED0805
R1, R2, R3, R4, R5, R6, R7, R9, R10: 1k; R0603@1
X4, X5, X6, X7: B2B-XH-2; B2B-XH-A

Connections:
3V3: LED8.A, X4.1, X5.1, X6.1, X7.1; also elsewhere on the board
5V: LED9.A; also elsewhere on the board
GND: R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R9.2, R10.2, X4.2, X5.2, X6.2, X7.2; also elsewhere on the board
unnamed: LED2.C, R1.1
unnamed: LED1.C, R2.1
unnamed: LED3.C, R3.1
unnamed: LED4.C, R4.1
unnamed: LED5.C, R5.1
unnamed: LED6.C, R6.1
unnamed: LED7.C, R7.1
unnamed: LED9.C, R10.1
unnamed: LED8.C, R9.1
PA1: LED2.A; also elsewhere on the board
PA2: LED1.A; also elsewhere on the board
PB10: LED3.A; also elsewhere on the board
PB11: LED7.A; also elsewhere on the board
PB13: LED4.A; also elsewhere on the board
PB14: LED5.A; also elsewhere on the board
PB15: LED6.A; also elsewhere on the board

Notes on the sheet:
インジゲータ
電源確認用
Other

Board: 2 copper layers, 77.0 x 97.0 mm, 58 parts (16 on the bottom side), 57 nets.

## EAGLE design 2023/controller_keinz_2023-main/Controller_Keinz_2023.brd

File 2023/controller_keinz_2023-main/README.md:

# Controller_Keinz_2023

## Getting started

To make it easy for you to get started with GitLab, here's a list of recommended next steps.

Already a pro? Just edit this README.md and make it your own. Want to make it easy? [Use the template at the bottom](#editing-this-readme)!

## Add your files

- [ ] [Create](https://docs.gitlab.com/ee/user/project/repository/web_editor.html#create-a-file) or [upload](https://docs.gitlab.com/ee/user/project/repository/web_editor.html#upload-a-file) files
- [ ] [Add files using the command line](https://docs.gitlab.com/ee/gitlab-basics/add-file.html#add-a-file-using-the-command-line) or push an existing Git repository with the following command:

```
cd existing_repo
git remote add origin https://gitlab.com/grcc/circuit/product/controller/controller_keinz_2023.git
git branch -M main
git push -uf origin main
```

## Integrate with your tools

- [ ] [Set up project integrations](https://gitlab.com/grcc/circuit/product/controller/controller_keinz_2023/-/settings/integrations)

## Collaborate with your team

- [ ] [Invite team members and collaborators](https://docs.gitlab.com/ee/user/project/members/)
- [ ] [Create a new merge request](https://docs.gitlab.com/ee/user/project/merge_requests/creating_merge_requests.html)
- [ ] [Automatically close issues from merge requests](https://docs.gitlab.com/ee/user/project/issues/managing_issues.html#closing-issues-automatically)
- [ ] [Enable merge request approvals](https://docs.gitlab.com/ee/user/project/merge_requests/approvals/)
- [ ] [Automatically merge when pipeline succeeds](https://docs.gitlab.com/ee/user/project/merge_requests/merge_when_pipeline_succeeds.html)

## Test and Deploy

Use the built-in continuous integration in GitLab.

- [ ] [Get started with GitLab CI/CD](https://docs.gitlab.com/ee/ci/quick_start/index.html)
- [ ] [Analyze your code for known vulnerabilities with Static Application Security Testing(SAST)](https://docs.gitlab.com/ee/user/application_security/sast/)
- [ ] [Deploy to Kubernetes, Amazon EC2, or Amazon ECS using Auto Deploy](https://docs.gitlab.com/ee/topics/autodevops/requirements.html)
- [ ] [Use pull-based deployments for improved Kubernetes management](https://docs.gitlab.com/ee/user/clusters/agent/)
- [ ] [Set up protected environments](https://docs.gitlab.com/ee/ci/environments/protected_environments.html)

***

# Editing this README

When you're ready to make this README your own, just edit this file and use the handy template below (or feel free to structure it however you want - this is just a starting point!). Thank you to [makeareadme.com](https://www.makeareadme.com/) for this template.

## Suggestions for a good README
Every project is different, so consider which of these sections apply to yours. The sections used in the template are suggestions for most open source projects. Also keep in mind that while a README can be too long and detailed, too long is better than too short. If you think your README is too long, consider utilizing another form of documentation rather than cutting out information.

## Name
Choose a self-explaining name for your project.

## Description
Let people know what your project can do specifically. Provide context and add a link to any reference visitors might be unfamiliar with. A list of Features or a Background subsection can also be added here. If there are alternatives to your project, this is a good place to list differentiating factors.

## Badges
On some READMEs, you may see small images that convey metadata, such as whether or not all the tests are passing for the project. You can use Shields to add some to your README. Many services also have instructions for adding a badge.

## Visuals
Depending on what you are making, it can be a good idea to include screenshots or even a video (you'll frequently see GIFs rather than actual videos). Tools like ttygif can help, but check out Asciinema for a more sophisticated method.

## Installation
Within a particular ecosystem, there may be a common way of installing things, such as using Yarn, NuGet, or Homebrew. However, consider the possibility that whoever is reading your README is a novice and would like more guidance. Listing specific steps helps remove ambiguity and gets people to using your project as quickly as possible. If it only runs in a specific context like a particular programming language version or operating system or has dependencies that have to be installed manually, also add a Requirements subsection.

## Usage
Use examples liberally, and show the expected output if you can. It's helpful to have inline the smallest example of usage that you can demonstrate, while providing links to more sophisticated examples if they are too long to reasonably include in the README.

## Support
Tell people where they can go to for help. It can be any combination of an issue tracker, a chat room, an email address, etc.

## Roadmap
If you have ideas for releases in the future, it is a good idea to list them in the README.

## Contributing
State if you are open to contributions and what your requirements are for accepting them.

For people who want to make changes to your project, it's helpful to have some documentation on how to get started. Perhaps there is a script that they should run or some environment variables that they need to set. Make these steps explicit. These instructions could also be useful to your future self.

You can also document commands to lint the code or run tests. These steps help to ensure high code quality and reduce the likelihood that the changes inadvertently break something. Having instructions for running tests is especially helpful if it requires external setup, such as starting a Selenium server for testing in a browser.

## Authors and acknowledgment
Show your appreciation to those who have contributed to the project.

## License
For open source projects, say how it is licensed.

## Project status
If you have run out of energy or time for your project, put a note at the top of the README saying that development has slowed down or stopped completely. Someone may choose to fork your project or volunteer to step in as a maintainer or owner, allowing your project to keep going. You can also make an explicit request for maintainers.

Parts:
C1, C2, C3, C4, C12: 100n; C0603K
C5: 4.7u; C0603K
C6: 10n; C0603K
C7: 1u; C0603K
C11: 10u; C0603K
C25, C26: 22p; CAPC1709X100N
FEP_1: GOD_OF_FEP
IC1: STM32F302C8T6; QFP50P900X900X160-48N
IC2: MCP3208-CI_P; DIP781W56P254L1918H533Q16N
IC3: LD1117S33CTR; SOT230P700X190-4N
Q1, Q4, Q6, Q8: BSS138LT7G; SOT96P237X111-3N
R5: 300; 1608
R8: 10k; R0603
R11, R12, R17, R18, R21, R22, R25, R26: 10k; SMD1608
X9: PN87520-S
X22: B2B-XH-2; B2B-XH-A
Y1: LFXTAL072100REEL

Connections:
3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C11.1, IC1.1 (VBAT), IC1.9 (VDDA/VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC3.2 (VOUT), IC3.4 (VOUT_1), Q1.1 (G), Q4.1 (G), Q6.1 (G), Q8.1 (G), R11.1, R17.1, R21.1, R25.1; also elsewhere on the board
5V: C12.1, FEP_1.P17 (5V), IC2.15 (VREF), IC2.16 (VDD), IC3.3 (VIN), R12.1, R18.1, R22.1, R26.1, X22.2; also elsewhere on the board
5V_MISO: IC2.12 (DOUT), Q1.3 (D), R12.2
5V_MOSI: IC2.11 (DIN), Q8.3 (D), R26.2
5V_NSS: IC2.10 (!CS!/SHDN), Q6.3 (D), R22.2
5V_SCK: IC2.13 (CLK), Q4.3 (D), R18.2
5V_USB: X9.1, X22.1
ADC-0: IC2.1 (CH0); also elsewhere on the board
ADC-1: IC2.2 (CH1); also elsewhere on the board
ADC-2: IC2.3 (CH2); also elsewhere on the board
ADC-3: IC2.4 (CH3); also elsewhere on the board
ADC-4: IC2.5 (CH4); also elsewhere on the board
ADC-5: IC2.6 (CH5); also elsewhere on the board
ADC-6: IC2.7 (CH6); also elsewhere on the board
DP0: IC1.10 (PA0); also elsewhere on the board
DP1: IC1.11 (PA1); also elsewhere on the board
DP2: IC1.12 (PA2); also elsewhere on the board
DP3: IC1.13 (PA3); also elsewhere on the board
DP4: IC1.14 (PA4); also elsewhere on the board
DP5: IC1.15 (PA5); also elsewhere on the board
DP6: IC1.16 (PA6); also elsewhere on the board
DP7: IC1.17 (PA7); also elsewhere on the board
DP8: IC1.18 (PB0); also elsewhere on the board
DP9: IC1.19 (PB1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C11.2, C12.2, C25.2, C26.2, FEP_1.P18 (GND), IC1.8 (VSSA/VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.9 (DGND), IC2.14 (AGND), IC3.1 (GROUND), R8.1, X9.4; also elsewhere on the board
I2C1_SCL: IC1.42 (PB6); also elsewhere on the board
I2C1_SDA: IC1.43 (PB7); also elsewhere on the board
I2C2_SCL: IC1.30 (PA9); also elsewhere on the board
I2C2_SDA: IC1.31 (PA10); also elsewhere on the board
unnamed: C25.1, R5.1, Y1.2 (CRYSTAL_2)
unnamed: IC1.44 (BOOT0), R8.2
NRST: IC1.7 (NRST); also elsewhere on the board
OSC_IN: C26.1, IC1.5 (PF0-OSC_IN), Y1.1 (CRYSTAL_1)
OSC_OUT: IC1.6 (PF1-OSC_OUT), R5.2
PB2: IC1.20 (PB2); also elsewhere on the board
PB10: IC1.21 (PB10); also elsewhere on the board
PB11: IC1.22 (PB11); also elsewhere on the board
PB12: IC1.25 (PB12); also elsewhere on the board
PB15: IC1.28 (PB15); also elsewhere on the board
SPI3_MISO: IC1.40 (PB4), Q1.2 (S), R11.2
SPI3_MOSI: IC1.41 (PB5), Q8.2 (S), R25.2
SPI3_NSS: IC1.38 (PA15), Q6.2 (S), R21.2
SPI3_SCK: IC1.39 (PB3), Q4.2 (S), R17.2
SWCLK: IC1.37 (PA14); also elsewhere on the board
SWDIO: IC1.34 (PA13); also elsewhere on the board
USART3_CTS: FEP_1.P12 (CTS), IC1.26 (PB13)
USART3_RTS: FEP_1.P13 (RTS), IC1.27 (PB14)
USART3_RX: FEP_1.P14 (DATA_RX), IC1.45 (PB8)
USART3_TX: FEP_1.P15 (DATA_TX), IC1.46 (PB9)
USB_DM: IC1.32 (PA11), X9.3
USB_DP: IC1.33 (PA12), X9.2

Notes on the sheet:
VDD-VSS
VDDA-VSSA
Level-Shift
Power Supply
Power Supply Sheme
FEP module
ADC-IC
Controller_Keinz_2023

Parts:
C8, C13: 0.1u; C0603K
CN3, CN14: B4B-XH-2; B4B-XH-A
JP3: PINHD-2X10; 2X10
S1, S2: DTSM-65N-V-T_R; DTSM65NVTR
SL1: MA06; 06PA
X2, X3: B4B-XH-2; B4B-XH-A
X8: S3B-XH-A

Connections:
3V3: CN3.1, CN14.1, SL1.1; also elsewhere on the board
5V: X2.1, X3.1; also elsewhere on the board
ADC-0: X8.3; also elsewhere on the board
ADC-1: X8.2; also elsewhere on the board
ADC-2: X8.1; also elsewhere on the board
ADC-3: X2.2; also elsewhere on the board
ADC-4: X2.3; also elsewhere on the board
ADC-5: X3.2; also elsewhere on the board
ADC-6: X3.3; also elsewhere on the board
DP0: JP3.1; also elsewhere on the board
DP1: JP3.3; also elsewhere on the board
DP2: JP3.5; also elsewhere on the board
DP3: JP3.7; also elsewhere on the board
DP4: JP3.9; also elsewhere on the board
DP5: JP3.11; also elsewhere on the board
DP6: JP3.13; also elsewhere on the board
DP7: JP3.15; also elsewhere on the board
DP8: JP3.17; also elsewhere on the board
DP9: JP3.19; also elsewhere on the board
GND: C8.2, C13.2, CN3.4, CN14.4, JP3.2, JP3.4, JP3.6, JP3.8, JP3.10, JP3.12, JP3.14, JP3.16, JP3.18, JP3.20, S1.3 (NO_1), S2.3 (NO_1), SL1.3, X2.4, X3.4; also elsewhere on the board
I2C1_SCL: CN14.2; also elsewhere on the board
I2C1_SDA: CN14.3; also elsewhere on the board
I2C2_SCL: CN3.2; also elsewhere on the board
I2C2_SDA: CN3.3; also elsewhere on the board
NRST: C13.1, S1.1 (COM_1), SL1.5; also elsewhere on the board
PB11: C8.1, S2.1 (COM_1); also elsewhere on the board
SWCLK: SL1.2; also elsewhere on the board
SWDIO: SL1.4; also elsewhere on the board

Notes on the sheet:
I/O
チャタリング防止用

Parts:
LED1, LED2, LED3, LED4, LED8, LED9: LEDCHIP-LED0805; CHIP-LED0805
R1, R2, R3, R4, R9, R10: 1k; R0603
X4, X5, X6, X7: S2B-XH-A

Connections:
3V3: LED9.A, X4.1, X5.1; also elsewhere on the board
5V: LED8.A, X6.1, X7.1; also elsewhere on the board
GND: R1.2, R2.2, R3.2, R4.2, R9.2, R10.2, X4.2, X5.2, X6.2, X7.2; also elsewhere on the board
unnamed: LED2.C, R1.1
unnamed: LED1.C, R2.1
unnamed: LED3.C, R3.1
unnamed: LED4.C, R4.1
unnamed: LED9.C, R10.1
unnamed: LED8.C, R9.1
PB2: LED2.A; also elsewhere on the board
PB10: LED1.A; also elsewhere on the board
PB12: LED4.A; also elsewhere on the board
PB15: LED3.A; also elsewhere on the board

Notes on the sheet:
インジゲータ
電源確認用
Other

Board: 2 copper layers, 63.0 x 68.0 mm, 59 parts (17 on the bottom side), 57 nets.
