# Repository shinchiryota/Circuit

File README.md:

# Circuit
2022以降の回路をまとめる

## [諸注意](諸注意)
+ [使用するソフトウェア](諸注意/使用するソフトウェア/readme.md)
+ [ファイル構成](諸注意/ファイル構成/readme.md)
+ [命名規則](諸注意/命名規則/readme.md)

## [2022](https://github.com/shinchiryota/Circuit/blob/main/2022/README.md)
+ servo_solenoidvalve_of_Tatebayashi

+ unitbase_keinz_2022

+ controller_keinz_2022
## [2023](https://github.com/shinchiryota/Circuit/blob/main/2023/README.md)
+ controller_keinz_2023

+ sensormain_of_sawada

+ servosolenoidvalve_of_tanbo

+ unitbase_anayuki
## [2024](https://github.com/shinchiryota/Circuit/blob/main/2024/README.md)
+ Power_of_Exodia

+ Unitbase_of_exoia
+ ### [nhk2024](https://github.com/shinchiryota/Circuit/blob/main/2024/nhk2024/README.md)

## EAGLE design fep/Fep_Exodia/ver2/FEP_of_Exodia ver2.brd

File fep/Fep_Exodia/ver2/README.md:

# FEP_of_Exodia
fep02用に新しく開発したfep基板です。god_of_fepを参考にしてます。

## 回路図

## スケマティック

Parts:
5V: LED1608
C1: 1u; C0603
C23: 100n; CAPC1709X100N
DATA_LED: KM-23ESGW; SOT-23
R1: 10k; R0603
R2, R3, R4, R5, R6: 300; R0603
S1: EG2209A
S2: TSHA-T-2.5B2-19E; TSHAT25B219E
SV1, SV2: MA10-1
SV3: MA04-1
U1: FEP02
WRITE_LED: KM-23ESGW; SOT-23
X1: S4B-XH-A

Connections:
5V: C1.1, R1.2, R4.1, SV2.4, SV3.1, U1.1 (VCC), U1.13 (POWER_ON), X1.1
CTS: SV2.7, U1.5 (CTS)
DATA_RX: R3.1, S1.4 (NC_2), SV2.9, X1.4
DATA_TX: R2.1, S1.1 (NC_1), SV2.10, X1.3
GND: 5V.K, C1.2, C23.1, DATA_LED.3 (COMMON_CATHODE), S2.C1 (COM_1), S2.D1 (COM_2), SV2.3, SV3.2, U1.14 (GND), WRITE_LED.3 (COMMON_CATHODE), X1.2
INIT: C23.2, S2.A1 (NO_1), U1.11 (!INI)
unnamed: DATA_LED.1 (ANODE_RED), R3.2
unnamed: DATA_LED.2 (ANODE_GREEN), R2.2
unnamed: 5V.A, R4.2
unnamed: R6.2, WRITE_LED.1 (ANODE_RED)
unnamed: R5.2, WRITE_LED.2 (ANODE_GREEN)
RESET: R1.1, U1.12 (!RST)
RTS: SV2.8, U1.4 (RTS)
USART_RX: S1.5 (COM_2), U1.2 (RXD)
USART_TX: S1.2 (COM_1), U1.3 (TXD)
WRITE_RX: R6.1, S1.6 (NO_2), SV2.6, SV3.4
WRITE_TX: R5.1, S1.3 (NO_1), SV2.5, SV3.3

Notes on the sheet:
Connector
Support
riset
LED
Option

Board: 2 copper layers, 52.0 x 42.0 mm, 18 parts (3 on the bottom side), 17 nets.

## EAGLE design fep/god_of_fep/FEP.brd

Parts:
5V_LED: LED_E; LED_1206
C1: 1u; C0603
CN1: S4B-XASK-1
DATA_LED: KM-23ESGW; SOT-23
FEP_1: FEP01
R1: 10k; R0603
R2, R3, R4, R5, R6: 300; R0603
SV1, SV2: MA10-1
SV3: MA04-1
SW_1: P-03647_TS-0606; TS-0606
SW_3: P-08784_PS-70S; PS-70S
WRITE_LED: KM-23ESGW; SOT-23

Connections:
5V: C1.1, CN1.1, FEP_1.P4 (VCC), FEP_1.P16 (POWER), R1.2, R4.1, SV2.4, SV3.1
CTS: FEP_1.P8 (CTS), SV2.7
DATA_RX: CN1.4, R3.1, SV2.9, SW_3.P4
DATA_TX: CN1.3, R2.1, SV2.10, SW_3.P1
GND: 5V_LED.C, C1.2, CN1.2, DATA_LED.3 (COMMON_CATHODE), FEP_1.P17 (GND), SV2.3, SV3.2, SW_1.P3, WRITE_LED.3 (COMMON_CATHODE)
INIT: FEP_1.P14 (/INI), SW_1.P1
unnamed: DATA_LED.1 (ANODE_RED), R3.2
unnamed: DATA_LED.2 (ANODE_GREEN), R2.2
unnamed: 5V_LED.A, R4.2
unnamed: R6.2, WRITE_LED.1 (ANODE_RED)
unnamed: R5.2, WRITE_LED.2 (ANODE_GREEN)
RESET: FEP_1.P15 (/RST), R1.1
RTS: FEP_1.P7 (RTS), SV2.8
USART_RX: FEP_1.P5 (RXD), SW_3.P5
USART_TX: FEP_1.P6 (TXD), SW_3.P2
WRITE_RX: R6.1, SV2.6, SV3.4, SW_3.P6
WRITE_TX: R5.1, SV2.5, SV3.3, SW_3.P3

Notes on the sheet:
Connector
FEP
Switch
Option
LED
Support

Board: 2 copper layers, 63.0 x 36.7 mm, 17 parts (6 on the bottom side), 17 nets.

## EAGLE design 2024/nhk2024/Sensormain_Exodia/sensormain_Exodia ver2.brd

File 2024/README.md:

# 2024年度の回路
+ Power_of_Exodia
 
+ Unitbase_of_exodia
## [nhk2024](https://github.com/shinchiryota/Circuit/tree/main/2024/nhk2024)

# [始めに戻る](https://github.com/shinchiryota/Circuit/blob/main/README.md)

Parts:
3V3, 5V: LED1608
C1, C3, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C18, C23: 100n; CAPC1709X100N
C2: 10uF; CAPC1608X90N
C4, C19: 1u; CAPC1709X100N
C17: 4.7u; CAPC1709X100N
C20, C21: 2.2u; CAPC1709X100N
C22: 100n; CAPC1608X90N
CAN_RX: LED1608
CAN_TX: LED1608
IC1: STM32F732RET6; QFP50P1200X1200X160-64N
IC2: NCV7351D1ER2G; SOIC127P600X175-8N
J1, J2: USB-4AF203AS; USB4AF203AS
Q9, Q10: SOT-23_NMOS; SOT-23
R1: 10k; 1608
R2, R3, R75, R76: 1k; R0603
R5: 120; R0805
R77, R78: 10k; SMD1608
S1, S2: TSHA-T-2.5B2-19E; TSHAT25B219E
SL1: MA06; 06PA
U1: LD1117S33CTR; SOT223
X22: S3B-XH-A

Connections:
3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, IC1.1 (VBAT), IC1.13 (VREF+), IC1.19 (VDD_1), IC1.32 (VDD_2), IC1.48 (VDD_3), IC1.64 (VDD_4), R2.1, S1.C1 (COM_1), SL1.1, U1.2 (OUT), U1.4 (OUT), X22.2; also elsewhere on the board
5V: C22.2, CAN_RX.A, CAN_TX.A, IC2.3 (VCC), IC2.5 (EN), J1.1, J1.5, J2.1, J2.5, R3.1, U1.3 (IN), X22.1; also elsewhere on the board
CANH: IC2.7 (CANH), J1.2, J1.6, J2.2, J2.6, R5.2
CANL: IC2.6 (CANL), J1.3, J1.7, J2.3, J2.7, R5.1
CAN_RX: IC1.44 (PA11), IC2.4 (RXD), R78.2
CAN_TX: IC1.45 (PA12), IC2.1 (TXD), R77.2
ENCODER1-A: IC1.14 (PA0-WKUP); also elsewhere on the board
ENCODER1-B: IC1.15 (PA1); also elsewhere on the board
ENCODER2-A: IC1.37 (PC6); also elsewhere on the board
ENCODER2-B: IC1.38 (PC7); also elsewhere on the board
ENCODER3-A: IC1.41 (PA8); also elsewhere on the board
ENCODER3-B: IC1.42 (PA9); also elsewhere on the board
ENCODER4-A: IC1.50 (PA15); also elsewhere on the board
ENCODER4-B: IC1.55 (PB3); also elsewhere on the board
ENCODER5-A: IC1.56 (PB4); also elsewhere on the board
ENCODER5-B: IC1.57 (PB5); also elsewhere on the board
ENCODER6-A: IC1.58 (PB6); also elsewhere on the board
ENCODER6-B: IC1.59 (PB7); also elsewhere on the board
GND: 3V3.K, 5V.K, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, IC1.12 (VSSA), IC1.18 (VSS_1), IC1.31 (VSS_2), IC1.47 (VSS_3), IC1.63 (VSS_4), IC2.2 (GND), IC2.8 (S), J1.4, J1.8, J2.4, J2.8, Q9.2 (S), Q10.2 (S), R1.2, S2.C1 (COM_1), S2.D1 (COM_2), SL1.3, U1.1 (GND), X22.3; also elsewhere on the board
unnamed: 3V3.A, R2.2
unnamed: 5V.A, R3.2
unnamed: IC1.60 (BOOT0), R1.1
unnamed: Q9.1 (G), R77.1
unnamed: Q10.1 (G), R78.1
unnamed: CAN_TX.K, R75.1
unnamed: CAN_RX.K, R76.1
unnamed: Q9.3 (D), R75.2
unnamed: Q10.3 (D), R76.2
NRST: C23.2, IC1.7 (NRST), S2.A1 (NO_1), SL1.5
PA10: IC1.43 (PA10); also elsewhere on the board
PB0: IC1.25 (PB0); also elsewhere on the board
PB1: IC1.26 (PB1); also elsewhere on the board
PB2: IC1.27 (PB2); also elsewhere on the board
PC1: IC1.9 (PC1); also elsewhere on the board
PC2: IC1.10 (PC2); also elsewhere on the board
PC4: IC1.24 (PC4); also elsewhere on the board
PC8: IC1.39 (PC8); also elsewhere on the board
PC9: IC1.40 (PC9); also elsewhere on the board
PC13: IC1.2 (PC13); also elsewhere on the board
PC14: IC1.3 (PC14-OSC32_IN); also elsewhere on the board
PC15: C1.2, IC1.4 (PC15-OSC32_OUT), S1.A1 (NO_1)
PH0: IC1.5 (PH0-OSC_IN); also elsewhere on the board
PH1: IC1.6 (PH1-OSC_OUT); also elsewhere on the board
SCL1: IC1.61 (PB8); also elsewhere on the board
SCL2: IC1.28 (PB10); also elsewhere on the board
SDA1: IC1.62 (PB9); also elsewhere on the board
SDA2: IC1.29 (PB11); also elsewhere on the board
SPI1_MISO: IC1.22 (PA6); also elsewhere on the board
SPI1_MOSI: IC1.23 (PA7); also elsewhere on the board
SPI1_NSS: IC1.20 (PA4); also elsewhere on the board
SPI1_SCK: IC1.21 (PA5); also elsewhere on the board
SPI2_MISO: IC1.35 (PB14); also elsewhere on the board
SPI2_MOSI: IC1.36 (PB15); also elsewhere on the board
SPI2_NSS: IC1.33 (PB12); also elsewhere on the board
SPI2_SCK: IC1.34 (PB13); also elsewhere on the board
SWCLK: IC1.49 (PA14), SL1.2
SWDIO: IC1.46 (PA13), SL1.4
SWO: SL1.6
UART_RX: IC1.54 (PD2); also elsewhere on the board
UART_TX: IC1.53 (PC12); also elsewhere on the board
USART1_RX: IC1.17 (PA3); also elsewhere on the board
USART1_TX: IC1.16 (PA2); also elsewhere on the board
USART2_RX: IC1.52 (PC11); also elsewhere on the board
USART2_TX: IC1.51 (PC10); also elsewhere on the board
VCAP: C20.2, C21.2, IC1.30 (VCAP_1)

Notes on the sheet:
VDD-VSS
VDDA-VSSA
Write/Debug
VCAP
VREF
5v 3v3 gnd
power
resetボタン
CANトランシーバー
5V降圧レギュレータ
USB
汎用ピン
STリンク
バイパスコンデンサ（パスコン）
インジケータ
userボタン

Parts:
1-A, 1-B, 2-A, 2-B, 3-A, 3-B, 4-A, 4-B, 5-A, 5-B, 6-A, 6-B: LED1608
R4, R7, R9, R11, R13, R15, R17, R19, R21, R47, R49, R53: 10k; SMD1608
R6, R8, R10, R12, R14, R16, R18, R20, R22, R48, R50, R54: 1k; SMD1608
TR1, TR2, TR3, TR4, TR5, TR6, TR7, TR8, TR9, TR15, TR16, TR21: 2SC2712GR; SOT-23
X1, X2, X3, X4, X5, X6: S5B-XH-A

Connections:
5V: R6.1, R8.1, R10.1, R12.2, R14.1, R16.1, R18.1, R20.1, R22.1, R48.1, R50.1, R54.1, X1.4, X2.4, X3.4, X4.4, X5.4, X6.4; also elsewhere on the board
ENCODER1-A: R47.1, X1.5; also elsewhere on the board
ENCODER1-B: R11.1, X1.3; also elsewhere on the board
ENCODER2-A: R49.1, X2.5; also elsewhere on the board
ENCODER2-B: R13.1, X2.3; also elsewhere on the board
ENCODER3-A: R53.1, X3.5; also elsewhere on the board
ENCODER3-B: R15.1, X3.3; also elsewhere on the board
ENCODER4-A: R4.1, X4.5; also elsewhere on the board
ENCODER4-B: R17.1, X4.3; also elsewhere on the board
ENCODER5-A: R7.1, X5.5; also elsewhere on the board
ENCODER5-B: R19.1, X5.3; also elsewhere on the board
ENCODER6-A: R9.1, X6.5; also elsewhere on the board
ENCODER6-B: R21.1, X6.3; also elsewhere on the board
GND: TR1.2 (S), TR2.2 (S), TR3.2 (S), TR4.2 (S), TR5.2 (S), TR6.2 (S), TR7.2 (S), TR8.2 (S), TR9.2 (S), TR15.2 (S), TR16.2 (S), TR21.2 (S), X1.1, X2.1, X3.1, X4.1, X5.1, X6.1; also elsewhere on the board
unnamed: 1-A.K, TR15.3 (D)
unnamed: 1-A.A, R48.2
unnamed: R49.2, TR16.1 (G)
unnamed: R47.2, TR15.1 (G)
unnamed: 2-A.K, TR16.3 (D)
unnamed: 2-A.A, R50.2
unnamed: R4.2, TR1.1 (G)
unnamed: R53.2, TR21.1 (G)
unnamed: 4-A.K, TR1.3 (D)
unnamed: 4-A.A, R6.2
unnamed: 3-A.K, TR21.3 (D)
unnamed: R7.2, TR2.1 (G)
unnamed: 5-A.K, TR2.3 (D)
unnamed: 5-A.A, R8.2
unnamed: R9.2, TR3.1 (G)
unnamed: 6-A.K, TR3.3 (D)
unnamed: 6-A.A, R10.2
unnamed: R11.2, TR4.1 (G)
unnamed: 1-B.K, TR4.3 (D)
unnamed: 1-B.A, R12.1
unnamed: 3-A.A, R54.2
unnamed: R13.2, TR5.1 (G)
unnamed: 2-B.K, TR5.3 (D)
unnamed: 2-B.A, R14.2
unnamed: R15.2, TR6.1 (G)
unnamed: 3-B.K, TR6.3 (D)
unnamed: 3-B.A, R16.2
unnamed: R17.2, TR7.1 (G)
unnamed: 4-B.K, TR7.3 (D)
unnamed: 4-B.A, R18.2
unnamed: R19.2, TR8.1 (G)
unnamed: 5-B.K, TR8.3 (D)
unnamed: 5-B.A, R20.2
unnamed: R21.2, TR9.1 (G)
unnamed: 6-B.A, R22.2
unnamed: 6-B.K, TR9.3 (D)

Notes on the sheet:
encoder

Parts:
IC4: MCP3208-CI_P; DIP781W56P254L1918H533Q16N
Q1, Q2, Q3, Q5: BSS138LT7G; SOT96P237X111-3N
R23, R24, R25, R26, R27, R28, R29, R30: 10k; SMD1608
R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R51, R52: RESISTOR-US1608; SMD1608
X7, X10, X20: B3B-XH-A
X12, X18, X21, X23, X25: S3B-XH-A

Connections:
3V3: Q1.1 (G), Q2.1 (G), Q3.1 (G), Q5.1 (G), R23.1, R25.1, R27.1, R29.1, R33.1, R35.1, R37.1, R39.1, R41.1, R43.1, R45.1, R51.1; also elsewhere on the board
5V: IC4.15 (VREF), IC4.16 (VDD), R24.1, R26.1, R28.1, R30.1, R34.1, R36.1, R38.1, R40.1, R42.1, R44.1, R46.1, R52.1; also elsewhere on the board
ADC0: IC4.1 (CH0), X12.2
ADC1: IC4.2 (CH1), X25.2
ADC2: IC4.3 (CH2), X7.2
ADC3: IC4.4 (CH3), X23.2
ADC4: IC4.5 (CH4), X10.2
ADC5: IC4.6 (CH5), X18.2
ADC6: IC4.7 (CH6), X20.2
ADC7: IC4.8 (CH7), X21.2
GND: IC4.9 (DGND), IC4.14 (AGND), X7.3, X10.3, X12.3, X18.3, X20.3, X21.3, X23.3, X25.3; also elsewhere on the board
MISO_5V: IC4.12 (DOUT), Q3.3 (D), R28.2
MOSI_5V: IC4.11 (DIN), Q2.3 (D), R26.2
unnamed: R33.2, R34.2, X25.1
unnamed: R35.2, R36.2, X12.1
unnamed: R37.2, R38.2, X7.1
unnamed: R39.2, R40.2, X23.1
unnamed: R41.2, R42.2, X10.1
unnamed: R43.2, R44.2, X18.1
unnamed: R45.2, R46.2, X20.1
unnamed: R51.2, R52.2, X21.1
NSS_5V: IC4.10 (!CS!/SHDN), Q1.3 (D), R24.2
SCK_5V: IC4.13 (CLK), Q5.3 (D), R30.2
SPI1_MISO: Q3.2 (S), R27.2; also elsewhere on the board
SPI1_MOSI: Q2.2 (S), R25.2; also elsewhere on the board
SPI1_NSS: Q1.2 (S), R23.2; also elsewhere on the board
SPI1_SCK: Q5.2 (S), R29.2; also elsewhere on the board

Notes on the sheet:
ADC
Level conversion

Parts:
R81, R82, R85, R86, R87, R88, R89, R90, R91, R92, R95, R96, R97, R98, R99, R100, R101, R102: RESISTOR-US1608; SMD1608
X24, X27, X32, X33, X34, X35: B3B-XH-A
X28, X29, X30: S3B-XH-A

Connections:
3V3: R81.1, R85.1, R87.1, R89.1, R91.1, R95.1, R97.1, R99.1, R101.1; also elsewhere on the board
5V: R82.1, R86.1, R88.1, R90.1, R92.1, R96.1, R98.1, R100.1, R102.1; also elsewhere on the board
GND: X24.3, X27.3, X28.3, X29.3, X30.3, X32.3, X33.3, X34.3, X35.3; also elsewhere on the board
unnamed: R81.2, R82.2, X24.1
unnamed: R85.2, R86.2, X27.1
unnamed: R87.2, R88.2, X28.1
unnamed: R89.2, R90.2, X29.1
unnamed: R91.2, R92.2, X30.1
unnamed: R95.2, R96.2, X32.1
unnamed: R97.2, R98.2, X33.1
unnamed: R99.2, R100.2, X34.1
unnamed: R101.2, R102.2, X35.1
PB0: X29.2; also elsewhere on the board
PB1: X30.2; also elsewhere on the board
PC1: X24.2; also elsewhere on the board
PC2: X27.2; also elsewhere on the board
PC4: X28.2; also elsewhere on the board
PC13: X34.2; also elsewhere on the board
PC14: X35.2; also elsewhere on the board
PH0: X32.2; also elsewhere on the board
PH1: X33.2; also elsewhere on the board

Notes on the sheet:
GPIO

Parts:
PA10: LED1608
PB2: LED1608
PC8, PC9: LED1608
R31, R32, R67, R68, R69, R70, R71, R72, R73, R74: 0; SMD1608
R55, R57, R59, R61, R63, R65: 10k; SMD1608
R56, R58, R60, R62, R64, R66: 1k; SMD1608
RX: LED1608
TR10, TR11, TR12, TR13, TR14, TR17: 2SC2712GR; SOT-23
TX: LED1608
X8, X9: S4B-XH-A
X11, X13: S3B-XH-A
X14, X17: B4B-XH-2; B4B-XH-A

Connections:
3V3: R31.2, R67.2, R69.2, R71.2, R73.2; also elsewhere on the board
5V: R32.2, R56.1, R58.1, R60.1, R62.1, R64.1, R66.1, R68.2, R70.2, R72.2, R74.2; also elsewhere on the board
GND: TR10.2 (S), TR11.2 (S), TR12.2 (S), TR13.2 (S), TR14.2 (S), TR17.2 (S), X9.4, X14.4, X17.4; also elsewhere on the board
unnamed: R55.2, TR10.1 (G)
unnamed: R31.1, R32.1, X9.1
unnamed: TR10.3 (D), TX.K
unnamed: R56.2, TX.A
unnamed: R57.2, TR11.1 (G)
unnamed: RX.K, TR11.3 (D)
unnamed: R58.2, RX.A
unnamed: R59.2, TR12.1 (G)
unnamed: PA10.K, TR12.3 (D)
unnamed: PA10.A, R60.2
unnamed: R61.2, TR13.1 (G)
unnamed: PC9.K, TR13.3 (D)
unnamed: PC9.A, R62.2
unnamed: R63.2, TR14.1 (G)
unnamed: PC8.K, TR14.3 (D)
unnamed: PC8.A, R64.2
unnamed: R65.2, TR17.1 (G)
unnamed: PB2.K, TR17.3 (D)
unnamed: PB2.A, R66.2
unnamed: R69.1, R70.1, X14.1
unnamed: R67.1, R68.1, X17.1
unnamed: R71.1, R72.1, X13.1
unnamed: R73.1, R74.1, X11.1
PA10: R59.1; also elsewhere on the board
PB2: R65.1; also elsewhere on the board
PC8: R63.1; also elsewhere on the board
PC9: R61.1; also elsewhere on the board
SCL1: X14.3; also elsewhere on the board
SCL2: X17.3; also elsewhere on the board
SDA1: X14.2; also elsewhere on the board
SDA2: X17.2; also elsewhere on the board
SPI2_MISO: X8.2; also elsewhere on the board
SPI2_MOSI: X8.1; also elsewhere on the board
SPI2_NSS: X8.4; also elsewhere on the board
SPI2_SCK: X8.3; also elsewhere on the board
UART_RX: X11.3; also elsewhere on the board
UART_TX: X11.2; also elsewhere on the board
USART1_RX: R57.1, X9.3; also elsewhere on the board
USART1_TX: R55.1, X9.2; also elsewhere on the board
USART2_RX: X13.3; also elsewhere on the board
USART2_TX: X13.2; also elsewhere on the board

Notes on the sheet:
spi
WirelessModule
i2c
u(s)art
indicator
